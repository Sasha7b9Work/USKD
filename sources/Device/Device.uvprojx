# Keil uVision project Device.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USDK +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects-Debug\USDK.axf --output USKD.bin
  AfterMake: HandlerBIN.exe USKD.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --cpp
  c include: .\src;..\common\Hardware\HAL;..\common\GD32F30x_Library\Firmware\GD32F30x_standard_peripheral\Include;..\common\GD32F30x_Library\Firmware\CMSIS;..\common\GD32F30x_Library\Firmware\CMSIS\GD\GD32F30x\Include;..\common
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group GD32F30x
    ../common/GD32F30x_Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_rtc.c gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_i2c.c gd32f30x_adc.c gd32f30x_dma.c gd32f30x_timer.c gd32f30x_misc.c gd32f30x_fmc.c gd32f30x_usart.c gd32f30x_spi.c gd32f30x_wwdgt.c gd32f30x_fwdgt.c gd32f30x_exti.c
    ../common/GD32F30x_Library/Firmware/GD32F30x_standard_peripheral/Include/: gd32f30x_rtc.h gd32f30x_gpio.h gd32f30x_rcu.h gd32f30x_adc.h gd32f30x_dma.h gd32f30x_timer.h gd32f30x_misc.h gd32f30x_fwdgt.h gd32f30x_exti.h
  group src
    ./src/: defines.h Device.h Device.cpp main.cpp
    ../common/: common_defines.h Globals.cpp Globals.h
  group Hardware
    ../common/Hardware/: Timer.cpp Timer.h
    ./src/Hardware/: Bootloader.cpp Bootloader.h Button.cpp Button.h LED.cpp LED.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32f30x_hd.s system_gd32f30x.c
  group Hardware/HAL
    ../common/Hardware/HAL/: gd32f30x_libopt.h HAL.cpp HAL.h HAL_ADC.cpp HAL_FWDGT.cpp HAL_I2C.cpp HAL_IT.cpp HAL_PINS.cpp HAL_PINS.h HAL_RTC.cpp HAL_USART.cpp systick.c systick.h HAL_ROM.cpp
  group Display
    ../common/Display/: Display.cpp Display.h SSD1306.cpp SSD1306.h
  group Display/Font
    ../common/Display/Font/: Font.cpp Font.h font5.inc font8.inc font10_7.inc
  group Modem
    ../common/Modem/: Parser.cpp Parser.h Modem.h Modem.cpp SIM868.h SIM868_transmit.cpp
    ./src/Modem/: SIM868.cpp ProcessorBinaryData.cpp ProcessorBinaryData.h
  group Modem/MQTT
    ./src/Modem/MQTT/: MQTT.cpp MQTT.h Sender.cpp Sender.h ResponseMQTT.cpp ResponseMQTT.h RequestMQTT.cpp RequestMQTT.h Messages.cpp Subscriptions.cpp Subscriptions.h
  group Modules/DHT22
    ./src/Modules/DHT22/: DHT22.cpp DHT22.h
  group Modules/GC777
    ./src/Modules/GC777/: GC777.h GC777.cpp
  group Modules/MPU6050
    ./src/Modules/MPU6050/: driver_mpu6050.cpp driver_mpu6050.h driver_mpu6050_basic.cpp driver_mpu6050_basic.h driver_mpu6050_code.h driver_mpu6050_interface.cpp driver_mpu6050_interface.h MPU6050.cpp MPU6050.h
  group Storage
    ./src/Storage/: Storage.cpp Storage.h MemoryStorage.cpp MemoryStorage.h
  group Utils
    ../common/Utils/: Buffer.h Math.h Log.cpp Log.h Debug.cpp Debug.h StringUtils.cpp StringUtils.h GlobalFunctions.cpp GlobalFunctions.h String.cpp String.h
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USDK +hex
  AfterMake: as above
  AfterMake: HandlerBIN.exe USKD.bin
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c misc: --cpp
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
